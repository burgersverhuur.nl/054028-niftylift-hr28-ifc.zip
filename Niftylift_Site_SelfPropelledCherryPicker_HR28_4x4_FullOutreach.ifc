Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-10-27T15:39:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 27 15:39:26 2020 * Host: ws-112 * Database: C:\Users\IAN~1.HOL\AppData\Local\Temp\{E6B0629C-7659-406F-ACF9-24BF423228A9}\ifc * Database version: 5507 * Database creation date: Tue Oct 27 15:39:25 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 27 15:39:25 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 27 15:39:25 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcTransportElement: HR28 4x4, Niftylift_Site_SelfPropelledCherryPicker_HR28_4x4:HR28 4x4:320082
In: Level 0
Type - PredefinedType: ELEVATOR; Classification: E1030100 Vehicular Service Equipment (Uniformat); Material: Rubber, Niftylift, Grey, Steel, Paint Finish, Niftylift, Black, Steel, Paint Finish, Niftylift, Green, Steel, Paint Finish, Niftylift, Grey, Steel, Paint Finish, Niftylift, Beige
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: Self Propelled Cherry Picker; Manufacturer: Niftylift; ProductionYear: 2020
